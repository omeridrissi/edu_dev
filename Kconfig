## Kconfig
```kconfig
config EDU_DEV
	tristate "QEMU virtual pci edu device driver"
	depends on PCI
	help
	  Enables EDU virutal pci device recognition and handling support.
```
